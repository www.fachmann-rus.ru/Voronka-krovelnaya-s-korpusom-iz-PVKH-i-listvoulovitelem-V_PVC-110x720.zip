Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-22T14:47:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Alternate UI 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 22 14:47:08 2020 * Host: 43-203-2 * Database: C:\Users\A8AC9~1.ZYA\AppData\Local\Temp\{9AA4757D-99D8-414D-8E4E-48DFBFCA55AB}\ifc * Database version: 5507 * Database creation date: Tue Sep 22 14:47:06 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 22 14:47:07 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 22 14:47:07 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
Phase: П

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Данные - ADSK_Титул_Год выпуска: 2019
Идентификация - Название организации: Название организации
Прочее - Адрес проекта: Адрес проекта; Дата утверждения проекта: Дата; Заказчик: Заказчик; Категория: Сведения о проекте; Статус проекта: П

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул_Год выпуска: 2019
Идентификация - Название организации: Название организации
Прочее - Категория: Сведения о проекте; Адрес проекта: Адрес проекта; Дата утверждения проекта: Дата; Заказчик: Заказчик; Статус проекта: П

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Зависимости - Фасад: 0 mm; Базовая отметка: Базовая точка проекта
Идентификация - Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes; Имя типа: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680

# IfcFlowTerminal: 110х720, BIMLIB_Воронка_Fachmann_V-PVC:110х720:166773
In: Этаж 01
Material: Fachmann_ПВХ_Черный, Fachmann_ПВХ_Белый
Pset_ManufacturerTypeInformation - Manufacturer: Fachmann
Pset_DistributionFlowElementCommon - Reference: 110х720
Зависимости - Рабочая плоскость: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Отметка по умолчанию: 1219.2 mm
Идентификация - Вариант конструкции: Главная модель; Марка: 7; ADSK_Версия семейства: 1; URL: https://fachmann-rus.ru/; Заголовок OmniClass: Roof Waste Water Drains; Изготовитель: Fachmann; Имя типа: 110х720; Номер OmniClass: 23.70.50.21.24.11; Описание: Кровельная воронка Fachmann V-PVC 110х450, V-PVC 110x720 с корпусом и листвоуловителем из ПВХ, с удлиненным вертикальным выпускным патрубком из ПП, используется для отвода дождевой и талой воды с плоских кровель во внутренний водосток дождевой канализации; Производитель_Контакты: Email: all@fachmann-rus.ru; Тел: 8 (800) 511-07-21; Разработчик_Контакты: support@bimlib.pro
Механизмы - ADSK_Расход жидкости: 0 m3/s; Классификация систем: Не определено; Fachmann_МаксимальныйРасход: 0.282517 m3/s
Прочее - a1: 187 mm; Категория: Сантехнические приборы; Код типа: BIMLIB_Воронка_Fachmann_V-PVC: 110х720; Семейство: BIMLIB_Воронка_Fachmann_V-PVC: 110х720; Семейство и типоразмер: BIMLIB_Воронка_Fachmann_V-PVC: 110х720; Тип: BIMLIB_Воронка_Fachmann_V-PVC: 110х720; Уровень спецификации: Уровень: Этаж 01; a2: 15 mm; a3: 35 mm; a4: 40 mm; a5: 50 mm; d1: 115 mm; d2: 362 mm; d3: 223 mm; Имя семейства: BIMLIB_Воронка_Fachmann_V-PVC
Размеры - ЛинияСреза: 3; Объем: 0.0124337 m3; ADSK_Диаметр условный: 110 mm; D_Листоуловитель: 165 mm; Fachmann_ВысотаВыпускногоПатрубка: 705 mm
Стадии - Стадия возведения: ПРОЕКТ
Данные - ADSK_URL документации изделия: https://fachmann-rus.ru/upload/iblock/f4e/f4ea93dc0c11299380ab01362b88a1a1.pdf; ADSK_URL страницы изделия: https://kirov.fachmann-rus.ru/catalog/krovelnye-voronki/675/; ADSK_Версия Revit: 2017; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: Fachmann; ADSK_Код изделия: 22.21.21.12.1.01.04; ADSK_Количество: 1; ADSK_Марка: V-PVC 110x720; ADSK_Наименование: Воронка кровельная с корпусом из ПВХ и листвоуловителем V-PVC 110x720 (арт. 01.143); ADSK_Наименование краткое: Воронка кровельная V-PVC 110x720
Текст - Fachmann_Артикул: 01.143; Fachmann_СрокСлужбы: не менее 50 лет; Fachmann_ТемператураОкружающейСреды: от -50 °С до +90 °С; Fachmann_ТемператураОтводящейЖидкости: не более +85 °С
